# Repository CalciumNitride/Popo-kbd

## KiCad design Arare_primary/Arare_primary.kicad_pcb

Parts:
BTN1: RESET; SW_SPST_SKQG_WithStem; MPN TS-1187A-B-A-B; LCSC C318884
C1, C5: 22pF; C_0603_1608Metric; MPN CL10C220JB8NNNC; LCSC C1653
C2, C3, C13, C15: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C4: 10uF; C_0402_1005Metric; MPN CL05A106MQ5NUNC; LCSC C15525
C6, C7, C8, C9, C10, C11, C12, C14, C16, C17: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
D1: ESD5Z5V0; D_SOD-523; MPN ESD5Z5V0; LCSC C502546
D2: 1N5819WS; D_SOD-323; LCSC C191023
F1: nSMD050-24V; Fuse_1206_3216Metric; MPN nSMD050-24V; LCSC C70076
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN GT-USB-7058; LCSC C165948
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J3, J4: Conn_01x08_MP; JUSHUO_AFC01-S08FCA-00_1x08-1MP_P0.5mm_Horizontal; MPN AFC01-S08FCA-00; LCSC C262657
R1, R6, R9: 1k; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
R2, R3: 27R; R_0603_1608Metric; MPN 0603WAF270JT5E; LCSC C25190
R4, R5: 5k1; R_0603_1608Metric; MPN 0603WAF5101T5E; LCSC C23186
R7, R8: 4.7k; R_0603_1608Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17: SW_Push; keyswitch_choc12_hotswap_1u
TP1: BOOT; testpoint_pad
U1: XC6206PxxxMR; SOT-23-3; MPN XC6206P332MR; LCSC C5446
U2: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; MPN RP2040; LCSC C2040
U3: USBLC6-2SC6; SOT-23-6; MPN USBLC6-2SC6; LCSC C2827654
U4: W25Q32JVUUIQ; Winbond_USON-8-2EP_3x4mm_P0.8mm_EP0.2x0.8mm; MPN W25Q32JVUUIQ; LCSC C2999380
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN X322512MSB4SI; LCSC C9002

Connections:
+1V1: C15.1, C16.1, C17.1, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C3.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, D2.2 (A), J3.1, J4.8, R1.2, R7.1, R8.1, U1.2 (VO), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_VIN), U2.48 (USB_VDD), U2.49 (IOVDD), U4.8 (VCC)
+5V: C2.1, F1.2, U1.3 (VI), U3.5 (VBUS)
/Boot: R6.1, TP1.1
/CS: R6.2, U2.56 (~QSPI_SS), U4.1 (~CS)
/DN: R3.1, U3.6 (I/O1)
/DP: R2.1, U3.4 (I/O2)
/QSPI_CLK: U2.52 (QSPI_SCLK), U4.6 (CLK)
/Reset: BTN1.1, R1.1, U2.26 (RUN)
/SCL: J3.7, U2.30 (GPIO19)
/SCL*: J2.A7 (D-), J2.B7 (D-), J4.2, R8.2
/SD0: U2.53 (QSPI_SD0), U4.5 (DI/IO_{0})
/SD1: U2.55 (QSPI_SD1), U4.2 (DO/IO_{1})
/SD2: U2.54 (QSPI_SD2), U4.3 (~WP/IO_{2})
/SD3: U2.51 (QSPI_SD3), U4.7 (~HOLD/~RESET/IO_{3})
/SDA: J3.5, U2.29 (GPIO18)
/SDA*: J2.A6 (D+), J2.B6 (D+), J4.4, R7.2
/USB_N: J1.A7 (D-), J1.B7 (D-), U3.1 (I/O1)
/USB_P: J1.A6 (D+), J1.B6 (D+), U3.3 (I/O2)
/USB_RN: R3.2, U2.46 (USB_DM)
/USB_RP: R2.2, U2.47 (USB_DP)
/XIN: C1.1, U2.20 (XIN), Y1.3
/XOUT: R9.2, U2.21 (XOUT)
/XOUT_R: C5.2, R9.1, Y1.1
/key1: SW1.2, U2.5 (GPIO3)
/key2: SW2.2, U2.7 (GPIO5)
/key3: SW3.2, U2.8 (GPIO6)
/key4: SW4.2, U2.14 (GPIO11)
/key5: SW5.2, U2.41 (GPIO29/ADC3)
/key6: SW6.2, U2.6 (GPIO4)
/key7: SW7.2, U2.9 (GPIO7)
/key8: SW8.2, U2.15 (GPIO12)
/key9: SW9.2, U2.16 (GPIO13)
/key10: SW10.2, U2.40 (GPIO28/ADC2)
/key11: SW11.2, U2.38 (GPIO26/ADC0)
/key12: SW12.2, U2.27 (GPIO16)
/key13: SW13.2, U2.28 (GPIO17)
/key14: SW14.2, U2.17 (GPIO14)
/key15: SW15.2, U2.39 (GPIO27/ADC1)
/key16: J3.2, U2.32 (GPIO21)
/key16*: J4.7, SW16.2
/key17: J3.3, U2.31 (GPIO20)
/key17*: J4.6, SW17.2
GND: BTN1.2, C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J3.4, J3.6, J3.8, J3.MP, J4.1, J4.3, J4.5, J4.MP, R4.2, R5.2, SW1.1, SW2.1, SW3.1, SW4.1, SW5.1, SW6.1, SW7.1, SW8.1, SW9.1, SW10.1, SW11.1, SW12.1, SW13.1, SW14.1, SW15.1, SW16.1, SW17.1, TP1.2, U1.1 (GND), U2.19 (TESTEN), U2.57 (GND), U3.2 (GND), U4.4 (GND), U4.9 (EP), Y1.2 (G), Y1.4 (G)
unnamed: D2.1 (K), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J1.A5 (CC1), R4.1
unnamed: J1.B5 (CC2), R5.1
VBUS: D1.1 (K), F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)

Notes on the sheet:
RP2040
※ADC_AVDD (43)の直近に配置する
VBUS ESD保護 & 過電流対策
RESET・BOOTボタン
水晶発振器
I2C プルアップ
※それぞれDVDD (23, 50)の直近に配置する
入力電源
※RP2040との信号線はできるだけ短くし（30mm以下推奨）、長さを揃える ※コンデンサーはVCCピンの直近に配置する
USB ESD保護
フラッシュストレージ
※コンデンサーは各ピンの直近に配置する
USB Type-C (左右接続)
キーマトリクス
※VREG_VOUT (45)の直近に配置する
USB Type-C (PC接続)
RP2040のバイパスコンデンサー
※それぞれIOVDD (1, 10, 22, 33, 42, 49)の直近に配置する ※49と隣接するUSB_VDD (48)にも併用して接続する
※VREG_IN (44)の直近に配置する

Board: 2 copper layers, 95.0 x 102.1 mm, 57 parts (52 on the bottom side), 48 nets.

## KiCad design Arare_secondary/Arare_secondary.kicad_pcb

Parts:
BTN1: RESET; SW_SPST_SKQG_WithStem; MPN TS-1187A-B-A-B; LCSC C318884
C1, C5: 22pF; C_0603_1608Metric; MPN CL10C220JB8NNNC; LCSC C1653
C2, C3, C13, C15: 1uF; C_0402_1005Metric; MPN CL05A105KA5NQNC; LCSC C52923
C4: 10uF; C_0402_1005Metric; MPN CL05A106MQ5NUNC; LCSC C15525
C6, C7, C8, C9, C10, C11, C12, C14, C16, C17: 100nF; C_0402_1005Metric; MPN CL05B104KO5NNNC; LCSC C1525
D1: ESD5Z5V0; D_SOD-523; MPN ESD5Z5V0; LCSC C502546
D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18: D; Diode_SMD
F1: nSMD050-24V; Fuse_1206_3216Metric; MPN nSMD050-24V; LCSC C70076
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; MPN GT-USB-7058; LCSC C165948
J2: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J3, J4: Conn_01x08_MP; JUSHUO_AFA07-S08FCA-00_1x8-1MP_P1.0mm_Horizontal; LCSC C262714
R1, R6: 1k; R_0603_1608Metric; MPN 0603WAF1001T5E; LCSC C21190
R2, R3: 27R; R_0603_1608Metric; MPN 0603WAF270JT5E; LCSC C25190
R4, R5: 5k1; R_0603_1608Metric; MPN 0603WAF5101T5E; LCSC C23186
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17: SW_Push; CherryMX_ChocV1V2_Hotswap_norev
TP1: BOOT; testpoint_pad
U1: XC6206PxxxMR; SOT-23-3; MPN XC6206P332MR; LCSC C5446
U2: RP2040; QFN-56-1EP_7x7mm_P0.4mm_EP3.2x3.2mm; MPN RP2040; LCSC C2040
U3: USBLC6-2SC6; SOT-23-6; MPN USBLC6-2SC6; LCSC C2827654
U4: W25Q32JVUUIQ; Winbond_USON-8-2EP_3x4mm_P0.8mm_EP0.2x0.8mm; MPN W25Q32JVUUIQ; LCSC C2999380
Y1: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN X322512MSB4SI; LCSC C9002

Connections:
+1V1: C15.1, C16.1, C17.1, U2.23 (DVDD), U2.45 (VREG_VOUT), U2.50 (DVDD)
+3V3: C3.1, C4.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, R1.2, U1.2 (VO), U2.1 (IOVDD), U2.10 (IOVDD), U2.22 (IOVDD), U2.33 (IOVDD), U2.42 (IOVDD), U2.43 (ADC_AVDD), U2.44 (VREG_VIN), U2.48 (USB_VDD), U2.49 (IOVDD), U4.8 (VCC)
+5V: C2.1, F1.2, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), J3.1, J4.1, U1.3 (VI), U3.5 (VBUS)
/Boot: R6.1, TP1.1
/COL0: SW5.1, SW10.1, SW15.1, U2.13 (GPIO10)
/COL1: SW1.1, SW6.1, SW11.1, U2.14 (GPIO11)
/COL2: SW2.1, SW7.1, SW12.1, U2.15 (GPIO12)
/COL3: J3.4, SW3.1, SW8.1, SW13.1, U2.16 (GPIO13)
/COL3*: J4.4, SW16.1
/COL4: J3.3, SW4.1, SW9.1, SW14.1, U2.17 (GPIO14)
/COL4*: J4.3, SW17.1
/CS: R6.2, U2.56 (~QSPI_SS), U4.1 (~CS)
/DN: R3.1, U3.4 (I/O2)
/DP: R2.1, U3.6 (I/O1)
/QSPI_CLK: U2.52 (QSPI_SCLK), U4.6 (CLK)
/ROW0: D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), U2.31 (GPIO20)
/ROW1: D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), U2.32 (GPIO21)
/ROW2: D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), U2.34 (GPIO22)
/ROW3: D16.1 (K), J3.7, U2.35 (GPIO23)
/ROW3*: D17.1 (K), D18.1 (K), J4.7
/Reset: BTN1.1, R1.1, U2.26 (RUN)
/SD0: U2.53 (QSPI_SD0), U4.5 (DI/IO_{0})
/SD1: U2.55 (QSPI_SD1), U4.2 (DO/IO_{1})
/SD2: U2.54 (QSPI_SD2), U4.3 (~WP/IO_{2})
/SD3: U2.51 (QSPI_SD3), U4.7 (~HOLD/~RESET/IO_{3})
/UART: J3.2, U2.3 (GPIO1)
/UART*: J2.A6 (D+), J2.B6 (D+), J4.2
/USB_N: J1.A7 (D-), J1.B7 (D-), U3.3 (I/O2)
/USB_P: J1.A6 (D+), J1.B6 (D+), U3.1 (I/O1)
/XIN: C1.1, U2.20 (XIN), Y1.3
/XOUT: C5.2, U2.21 (XOUT), Y1.1
GND: BTN1.2, C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.2 (A), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.SH (SHIELD), J3.8, J3.MP, J4.8, J4.MP, R4.2, R5.2, TP1.2, U1.1 (GND), U2.19 (TESTEN), U2.57 (GND), U3.2 (GND), U4.4 (GND), U4.9 (EP), Y1.2 (G), Y1.4 (G)
unnamed: D2.2 (A), SW1.2
unnamed: D3.2 (A), SW2.2
unnamed: D4.2 (A), SW3.2
unnamed: D5.2 (A), SW4.2
unnamed: D6.2 (A), SW5.2
unnamed: D7.2 (A), SW6.2
unnamed: D8.2 (A), SW7.2
unnamed: D9.2 (A), SW8.2
unnamed: D10.2 (A), SW9.2
unnamed: D11.2 (A), SW10.2
unnamed: D12.2 (A), SW11.2
unnamed: D13.2 (A), SW12.2
unnamed: D14.2 (A), SW13.2
unnamed: D15.2 (A), SW14.2
unnamed: D16.2 (A), SW15.2
unnamed: D17.2 (A), SW16.2
unnamed: D18.2 (A), SW17.2
unnamed: J1.A5 (CC1), R4.1
unnamed: J1.B5 (CC2), R5.1
unnamed: R3.2, U2.46 (USB_DM)
unnamed: R2.2, U2.47 (USB_DP)
VBUS: D1.1 (K), F1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS)

Notes on the sheet:
RP2040
※ADC_AVDD (43)の直近に配置する
VBUS ESD保護 & 過電流対策
RESET・BOOTボタン
水晶発振器
※それぞれDVDD (23, 50)の直近に配置する
入力電源
※RP2040との信号線はできるだけ短くし（30mm以下推奨）、長さを揃える ※コンデンサーはVCCピンの直近に配置する
USB ESD保護
フラッシュストレージ
※コンデンサーは各ピンの直近に配置する
USB Type-C (左右接続)
キーマトリクス
※VREG_VOUT (45)の直近に配置する
USB Type-C (PC接続)
RP2040のバイパスコンデンサー
※それぞれIOVDD (1, 10, 22, 33, 42, 49)の直近に配置する ※49と隣接するUSB_VDD (48)にも併用して接続する
※VREG_IN (44)の直近に配置する

Board: 2 copper layers, 96.2 x 95.0 mm, 72 parts (4 on the bottom side), 54 nets.

Other parts of the board:
MB**: MouseBite_Tab_5x9.5mm
MB**#2: MouseBite_Tab_5x9.5mm

## Commit log (part)

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2026-06-23 init
2026-06-23 ライブラリ整理
